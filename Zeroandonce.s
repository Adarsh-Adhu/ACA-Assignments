	AREA Zeroandonce,CODE, READONLY
	ENTRY
MAIN
	LDR R1,=0X40000000
	LDR R1,[R1]
	MOV R0,#1
	MOV R5,#0
LOOP
	CMP R5,#32
	BEQ L2
	ANDS R2,R1,R0
	BNE L1
	ADD R7,#1
	ADD R5,#1
	MOV R0,R0,LSL #1
	B LOOP
L1	ADD R6,#1
	ADD R5,#1
	MOV R0,R0,LSL #1
	B LOOP

L2
	LDR R8,=0X40000004
	STR R6,[R8]
	LDR R8,=0X40000008
	STR R7,[R8]
STOP B STOP	
	END